# Keil uVision project STM32F4-Discovery-blink-freertos.uvprojx, settings and files
target stm32f4_blink_freertos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: bin +hex
  c flags: Optim=1 oTime=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F4XX,HSE_VALUE=8000000
  c include: ..\;..\CMSIS\Include;..\CMSIS\STM32F4xx\Include;..\STM32F4_Discovery;..\STM32F4xx_StdPeriph_Driver\inc;..\startup;..\FreeRTOS\Source\include;..\FreeRTOS\Source\portable\RVDS\ARM_CM4F;..\FreeRTOS;..\MDK-ARM;.\TASKS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group main
    ../: main.c stm32f4xx_conf.h stm32f4xx_it.c
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_exti.c stm32f4xx_rcc.c misc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group Discovery
    ../STM32F4_Discovery/: discoveryf4utils.c
  group FreeRTOS
    ../FreeRTOS/Source/: tasks.c queue.c list.c croutine.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/: FreeRTOSConfig.h
  group startup
    ../startup/: startup_stm32f4xx.s system_stm32f4xx.c
  group TASKS
    ./TASKS/: blue_task.c red_task.c green_task.c orange_task.c pb_processing_task.c blue_task.h red_task.h green_task.h orange_task.h pb_proccessing_task.h
software components: CMSIS:CORE 5.6.0
